# Keil uVision project Wireless_Controller.uvproj, settings and files
target Wireless_Controller (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Wireless_Controller +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\Source\Application;..\Source\Device_Driver;..\Source\System;D:\Keil\C51\INC\STC
  group System
    ../Source/System/: Main.c Config.h hSch51.c hSch51.h
  group Application
    ../Source/Application/: Delay.c Download.c LCD1602_Clock.c Timer.c Delay.h Download.h LCD1602_Clock.h Timer.h LCD1602_Menu.c LCD1602_Menu.h LCD1602_Show.h LCD1602_Show.c ESP8266.c UART.c ESP8266.h UART.h EEPROM_Application.c EEPROM_Application.h
  group Device_Driver
    ../Source/Device_Driver/: LCD1602.c LCD1602.h Relay.c Relay.h EEPROM.c EEPROM.h EC11.c EC11.h Buzzer.c Buzzer.h
  group Readme
    ../Readme/: Readme.txt
